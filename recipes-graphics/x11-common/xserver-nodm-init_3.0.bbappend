RCONFLICTS_${PN} = "xserver-common (< 1.34-r9) "
