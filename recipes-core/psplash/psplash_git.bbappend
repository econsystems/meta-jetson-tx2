FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

SRC_URI +="file://psplash_econ_logo.patch \
		file://psplash-econ-img.h"

